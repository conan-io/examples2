inherit conan

DESCRIPTION = "An open source MQTT broker"
LICENSE = "EPL-1.0"
CONAN_PKG = "mosquitto/2.0.18"